# Keil uVision project EC11.uvproj, settings and files
target FLASH (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: EC11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\C51Lib;..\Fwlib;..\User;..\System\MyUART;..\System\MyTimer;..\menu;..\Hardware\LED;..\Hardware\key;..\Hardware\EC11;..\Hardware\OLED;..\Software\IIC
  group STARTUP
    ./: STARTUP.A51
  group FWLIB
    ../Fwlib/: delay.c GPIO.c timer.c UART.C ADC.c
  group SYSTEM
    ../System/MyTimer/: MyTimer.c
    ../System/MyUART/: MyUART.c
  group USER
    ../User/: main.c menu_event.c
  group MENU
    ../menu/: menu.c menu_link.c
  group HARDWARE
    ../Hardware/OLED/: screen.c oled.c
    ../Hardware/LED/: led.c
    ../Hardware/EC11/: EC11.c
    ../Hardware/key/: key.c
  group SOFTWARE
    ../Software/IIC/: iic.c
