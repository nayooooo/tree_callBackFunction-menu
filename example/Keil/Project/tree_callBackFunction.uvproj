# Keil uVision project tree_callBackFunction.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: tree_callBackFunction +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\C51Lib;..\Fwlib;..\User;..\System\MyTimer;..\Hardware\key;..\Hardware\OLED;..\Software\IIC;..\Menu;..\System\MyUART
  group STARTUP
    ./: STARTUP.A51
  group FWLIB
    ../Fwlib/: delay.c GPIO.c timer.c UART.C
  group USER
    ../User/: main.c menu_event.c
  group SYSTEM
    ../System/MyTimer/: MyTimer.c
    ../System/MyUART/: MyUART.c
  group HARDWARE
    ../Hardware/key/: key.c
    ../Hardware/OLED/: oled.c screen.c
  group SOFTWARE
    ../Software/IIC/: iic.c
  group MENU
    ../Menu/: menu.c menu_link.c
